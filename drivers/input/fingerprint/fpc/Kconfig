## drivers/input/fingerprint/fpc/Kconfig
```kconfig
config FINGERPRINT_FPC1020
	tristate "FPC1020 fingerprint sensor driver"
	help
	  Say Y here to enable fpc fingerprint driver support!
```
